# Keil uVision project GY_H1.uvprojx, settings and files
target GY-H1 (6190000::V6.19::ARMCLANG)
  device: GD32F303CE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GY_H1
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,__FPU_USED,__FPU_PRESENT,qwDbug
  c include: ..\GD32F30x_standard_peripheral\Include;..\GD32F30x_standard_peripheral\GD32F30x\Include;..\Drivers;..\Algorithm;..\RT-Thread\bsp;..\RT-Thread\include;..\RT-Thread\include\libc;..\DSP\Include;..\DSP\Include\dsp;..\DSP\PrivateInclude;..\RT-Thread\components\finsh;..\RT-Thread\components\device;..\GD32F30x_usbd_library\class\device\cdc\Include;..\GD32F30x_usbd_library\device\Include;..\GD32F30x_usbd_library\usbd\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FirmWare
    ../GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Driver
    ../GD32F30x_standard_peripheral/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    ../GD32F30x_standard_peripheral/GD32F30x/Source/: system_gd32f30x.c
    ../Drivers/: gd32f30x_it.c SPI_GD.cpp UART_GD.cpp WS281x.cpp ICM42688.cpp
  group Algorithm
    ../Algorithm/: main.cpp MsgThread.cpp IMU.cpp
  group DSP
    ../DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../DSP/Source/CommonTables/: CommonTables.c
    ../DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ../DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../DSP/Source/FilteringFunctions/: FilteringFunctions.c
    ../DSP/Source/InterpolationFunctions/: InterpolationFunctions.c
    ../DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../DSP/Source/SupportFunctions/: SupportFunctions.c
  group RT_Thread
    ../RT-Thread/bsp/: board.c rtconfig.h
    ../RT-Thread/components/device/: device.c
    ../RT-Thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../RT-Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../RT-Thread/components/finsh/: cmd.c
  group USB
    ../GD32F30x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
    ../GD32F30x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
    ../GD32F30x_usbd_library/class/device/cdc/Source/: cdc_acm_core.c
software components: CMSIS:CORE 5.6.0
